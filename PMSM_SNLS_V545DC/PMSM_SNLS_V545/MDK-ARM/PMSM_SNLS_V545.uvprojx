# Keil uVision project PMSM_SNLS_V545.uvprojx, settings and files
target PMSM_SNLS_V545 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PMSM_SNLS_V545 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4,USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;       ../Drivers/STM32F4xx_HAL_Driver/Inc;       ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;       ../MCSDK_v5.4.5-Full/MotorControl/MCSDK/MCLib/Any/Inc;       ../MCSDK_v5.4.5-Full/MotorControl/MCSDK/MCLib/F4xx/Inc;       ../MCSDK_v5.4.5-Full/MotorControl/MCSDK/UILibrary/Inc;       ../MCSDK_v5.4.5-Full/MotorControl/MCSDK/SystemDriveParams;       ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;       ../Drivers/CMSIS/Include;       ../Drivers/CMSIS/DSP/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c adc.c motorcontrol.c mc_api.c motor_control_protocol.c mc_config.c mc_tasks.c regular_conversion_manager.c mc_math.c mc_interface.c stm32f4xx_mc_it.c mc_parameters.c ui_task.c user_interface.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/MotorControl
    ../MCSDK_v5.4.5-Full/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c motor_power_measurement.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c pwm_curr_fdbk.c pwm_common.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c revup_ctrl.c speed_pos_fdbk.c speed_torq_ctrl.c state_machine.c sto_pll_speed_pos_fdbk.c virtual_speed_sensor.c
    ../MCSDK_v5.4.5-Full/MotorControl/MCSDK/MCLib/F4xx/Src/: r3_2_f4xx_pwm_curr_fdbk.c
    ../MCSDK_v5.4.5-Full/MotorControl/MCSDK/UILibrary/Src/: frame_communication_protocol.c ui_irq_handler.c usart_frame_communication_protocol.c
software components: CMSIS:CORE 4.3.0
